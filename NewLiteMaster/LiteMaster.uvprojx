# Keil uVision project LiteMaster.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F101RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LiteMaster +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: .\ComUSART;.\Libs;.\HardWare\inc;.\SystemStartup;.\Entery;.\CC110x;.\JSON;.\Key;.\LED;.\Net;.\Pakage;.\Resource;.\SIM;.\Console;.\DeviceManagement;.\CommentHeader;.\GopioExitDemo;.\CardsStore;.\Flash
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Libs
    ./Libs/: libsz.lib
  group ComUSART
    ./ComUSART/: usart2.c usart3.c
  group Entery
    ./Entery/: main.c systick.c
  group StartUp
    ./SystemStartup/: start.c stm32f10x_it.c startup_stm32f10x_hd.s cortexm3_macro.s
  group HardWare
    ./HardWare/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_systick.c stm32f10x_dma.c stm32f10x_exti.c
  group Sim
    ./SIM/: msg_sim.c sim.c
  group Net
    ./Net/: virtual_net.c virtual_net_handle_data.c
  group CC1101
    ./CC110x/: cc110x_adapter.c cc110x_hal.c cc110x_module.c spi_com.c
  group LED
    ./LED/: led.c
  group Key
    ./Key/: key.c
  group Pakage
    ./Pakage/: orient_pagkage.c sz_pakage.c
  group Json
    ./JSON/: sz_json.c
  group DeviceResource
    ./Resource/: LiteMasterResource.c
  group Console
    ./Console/: stm_console.c console_cmd.c
  group DeviceManagement
    ./DeviceManagement/: device_mangement.c device_handle_data.c device_pakage.c device_info.c
  group Flash
    ./Flash/: inner_flash.c
  group GpioExitDemo
    ./GopioExitDemo/: gpio_exit_demo.c
  group CardStore
    ./CardsStore/: cards_store.c
  group CommenFunc
    ./CommentHeader/: common_func.c
